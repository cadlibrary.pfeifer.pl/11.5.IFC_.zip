Properties of the parts of a building model (IFC4)

# File
Description: no view
File name: IC_KIESZEŃ_BELKOWA_B 1100.ifc
Time: 2026-06-26T11:16:58
Author: Aleksander Skuła
Organization: No Organization
Written by: ODA SDAI 25.4
Authorization: askula

# IfcBuildingElementProxy, B1100
In: PFEIFER_BSF_EL_GOT
AllplanAttributes - Poziom_Dolny: 0 m; Poziom_Górny: 0 m; V6: 0 m; V7: 0 m; V8: 0 m; V9: 0; Nazwa: B1100; Wykaz łańcuchów wymiarowych: 0; ID_komponentu_Allright: 0057PEb0000000011; Rodzaj rozliczenia: Szt; Nazwa obiektu: Element gotowy punktowy
